# Keil uVision project RTOSDemo.uvprojx, settings and files
target freertos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 uC99=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\..\Source\include;.\STM32F10xFWLib\inc;.\logger;.\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./: STM32F10x.s
    ./STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c cortexm3_macro_rvds.s
  group Demo
    ./serial/: serial.c
    ./: timertest.c main.c
  group FreeRTOS
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group Thrid-Part/logger
    ./logger/: logger.c ulog.c
